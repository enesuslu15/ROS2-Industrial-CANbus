Commit message: fix: change rotor to box for visible rotation, add JointState publisher

File: src/canbus_visualization/urdf/simple_motor.urdf (robot description, URDF)
Before this commit: robot simple_motor, 2 links, 1 joints
Links:
- link rotor: geometry visual box size=0.2 0.04 0.05
